# Repository lessthan00/wsy_kicad (continued)

## KiCad design PY32F002AW15S_mini_system_kicadv805_success_kicadv806_2024-11-16/PY32F002AW15S_mini_system_kicadv805/project/PY32F002AW15S_mini_system.kicad_pcb (continued)

Board: 2 copper layers, 70.0 x 30.0 mm, 27 parts (3 on the bottom side), 22 nets.

File PY32F002AW15S_mini_system_kicadv805_success_kicadv806_2024-11-16/PY32F002AW15S_mini_system_kicadv805/product/PY32F002AW15S_mini_system_bom_utf-8.csv:

"Reference","Value","Footprint","Qty","DNP","说明"
"C1,C4","10uF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","2","","独石电容"
"C2,C5,C6,C9,C10","100nF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","5","","独石电容"
"C3","100nF","PCM_Capacitor_SMD_AKL:C_0805_2012Metric","1","DNP (不作装配)",""
"C7,C8","30pF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","2","","独石电容"
"J1","USB_C_Receptacle_PowerOnly_6P","Connector_USB:USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal","1","",""
"J2","Conn_01x04","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1","",""
"J3,J5","Conn_01x10","Connector_PinHeader_2.54mm:PinHeader_1x10_P2.54mm_Vertical","2","",""
"LED1","红灯","PCM_LED_THT_AKL:LED_D3.0mm","1","",""
"LED2","绿灯","PCM_LED_THT_AKL:LED_D3.0mm","1","",""
"R1,R2","10KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2","","金属膜电阻 1% 0.25W"
"R3,R4","5.1KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2","","金属膜电阻 1% 0.25W"
"R5,R6","10kΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2","","金属膜电阻 1% 0.25W"
"SW1,SW2","SW_DIP_x01","Button_Switch_THT:SW_PUSH_6mm_H7.3mm","2","","6mm*6mm*7.5mm_4pin_key"
"U1","AZ1117IH-3.3TRE1","PCM_Package_TO_SOT_SMD_AKL:SOT-223-3_TabPin2","1","",""
"U2","PY32F002AW15S6TU","Package_SO:SOP-16_3.9x9.9mm_P1.27mm","1","",""
"X1","12MHz_±20ppm_20pF_HC-49S","wsylib:Crystal_HC49-U-3Pin_Vertical_change","1","",""

## KiCad design USB_HUB_SL2_1A_success_kicadv805_2024-10-26/USB_HUB_SL2_1A/project/USB_HUB_SL2_1A.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7, C8: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
H1, H2: MountingHole_3mm_Pad
R1, R2: 5.1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: SL2.1A; SOP-16_3.9x9.9mm_P1.27mm
USB1, USB3, USB4, USB5: USB_A; USB_A_Molex_67643_Horizontal
USB2: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
X1: 12MHz_±20ppm_20pF_HC-49S; Crystal_HC49-U-3Pin_Vertical_change

Connections:
/USBA1_D+: U1.2 (DP4), USB1.3 (D+)
/USBA1_D-: U1.1 (DM4), USB1.2 (D-)
/USBA2_D+: U1.4 (DP3), USB3.3 (D+)
/USBA2_D-: U1.3 (DM3), USB3.2 (D-)
/USBA3_D+: U1.6 (DP2), USB4.3 (D+)
/USBA3_D-: U1.5 (DM2), USB4.2 (D-)
/USBA4_D+: U1.8 (DP1), USB5.3 (D+)
/USBA4_D-: U1.7 (DM1), USB5.2 (D-)
/USBC_D+: U1.10 (DP), USB2.A6 (D+), USB2.B6 (D+)
/USBC_D-: U1.9 (DM), USB2.A7 (D-), USB2.B7 (D-)
/VDD18: C3.1, U1.14 (VDD18)
/VDD33: C2.1, U1.13 (VDD33)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, H1.1, H2.1, R1.1, R2.1, U1.12 (GND), USB1.4 (GND), USB1.5 (Shield), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), USB2.S1 (SHIELD), USB3.4 (GND), USB3.5 (Shield), USB4.4 (GND), USB4.5 (Shield), USB5.4 (GND), USB5.5 (Shield), X1.2
unnamed: U1.16 (XIN), X1.1
unnamed: U1.15 (XOUT), X1.3
unnamed: R2.2, USB2.A5 (CC1)
unnamed: R1.2, USB2.B5 (CC2)
VBUS: C1.1, C4.1, C6.1, C7.1, C8.1, U1.11 (VDD5), USB1.1 (VBUS), USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS), USB3.1 (VBUS), USB4.1 (VBUS), USB5.1 (VBUS)

Notes on the sheet:
基于SL2.0A的USB2.0hub typeC口带4个typeA口 --wsy

Board: 2 copper layers, 90.0 x 37.0 mm, 18 parts (0 on the bottom side), 18 nets.

## KiCad design li-chuang-di-wen-xing-cw32f030c8t6-kai-fa-ban_produce_kicadv805_2024-10-26/li-chuang-di-wen-xing-cw32f030c8t6-kai-fa-ban/redraw/project/redraw.kicad_pcb

Parts:
C1: 1uF; C0805; Manufacturer Part CL10A105KO8NNNC; LCSC Part Name 1uF ±10% 16V
C2: 100nF; C0805; Manufacturer Part CC0603KRX7R9BB104; LCSC Part Name 100nF ±10% 50V
C3, C4, C10: 100nF; C0805; Manufacturer Part GRM155R71H104KE14D; LCSC Part Name 100nF ±10% 50V
C5, C11: 1uF; C0805; Manufacturer Part CL05A105KP5NNNC; LCSC Part Name 1uF ±10% 10V
C6, C7, C8, C9: 100nF; C0603; Manufacturer Part GRM155R71H104KE14D; LCSC Part Name 100nF ±10% 50V
C12, C13, C14, C15: 12pF; C0603; Manufacturer Part 0402CG120J500NT; LCSC Part Name 12pF ±5% 50V
H1: HDR-TH_3P-P2.54-V-M
H2, H3: HDR-TH_20P-P2.54-V-M-1
H4: HDR-TH_4P-P2.54-V-M; HDR-TH_4P-P2.54-V-F
H6: HDR-TH_2P-P2.54-V-F
LED1, LED2: LED0603-RD_RED; LED0805-R-RD; Manufacturer Part NCD0603R1; LCSC Part Name NCD0603R1
Q1: AMS1117-3.3V; SOT-89-3_L4.5-W2.5-P1.50-LS4.2-BR; Manufacturer Part AMS1117-3.3V; LCSC Part Name 输入18V 输出3.3V 1A
R2, R6: 10kΩ; R0805; Manufacturer Part RC0402FR-0710KL; LCSC Part Name 厚膜电阻 10kΩ ±1% 62.5mW
R4, R5: 1kΩ; R0805; Manufacturer Part 0402WGF1001TCE; LCSC Part Name 1kΩ ±1% 62.5mW 厚膜电阻
R8, R9: 5.1kΩ; R0805; Manufacturer Part 0402WGF5101TCE; LCSC Part Name 5.1kΩ ±1% 62.5mW 厚膜电阻
SW1: TS-1101-B-W; KEY-SMD_2P-L6.0-W3.6-P7.4-LS8.0-L; Manufacturer Part TS-1101-B-W; LCSC Part Name 6*3.6*2.5mm 立贴 轻触开关
U1: CW32F030C8T6; LQFP-48_L7.0-W7.0-P0.50-LS9.0-TL; Manufacturer Part CW32F030C8T6; LCSC Part Name CW32F030C8T6
USB1: TYPE-C 16PIN 2MD(073); USB-C-SMD_TYPE-C-6PIN-2MD-073; Manufacturer Part TYPE-C 16PIN 2MD(073); LCSC Part Name TYPE-C母座 16P 4脚插件带定位柱 不锈钢外壳 2次模顶
X1: 8MHz; CRYSTAL-SMD_4P-L3.2-W2.5-BL-1; Manufacturer Part XL2EL89COI-111YLC-8M; LCSC Part Name 8MHz ±10ppm 12pF
X2: 32.768kHz; OSC-SMD_L3.2-W1.5; Manufacturer Part X321532768KGD2SI; LCSC Part Name 32.768kHz ±20ppm 12.5pF

Connections:
/VDDA: C9.1, H6.1, H6.2, U1.9 (VDDA)
BOOT0: R6.1, U1.44 (BOOT0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, H1.3, H2.2, H3.2, H4.1, LED1.2 (-), LED2.2 (-), Q1.1 (ADJ/GND), R8.2, R9.2, SW1.1, U1.8 (VSSA), U1.23 (VSS), U1.47 (VSS), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHELL), USB1.14 (SHELL), X1.2 (GND), X1.4 (GND)
NRST: C3.1, H2.4, R2.2, SW1.2, U1.7 (NRST)
unnamed: H1.2, R6.2
unnamed: LED1.1 (+), R4.1
unnamed: LED2.1 (+), R5.2
unnamed: R9.1, USB1.4 (CC1)
unnamed: R8.1, USB1.10 (CC2)
OSC32_IN: C14.1, U1.3 (PC14-OSC32_IN), X2.1
OSC32_OUT: C15.1, U1.4 (PC15-OSC32_OUT), X2.2
OSC_IN: C13.2, U1.5 (PF0-OSC_IN), X1.1
OSC_OUT: C12.1, U1.6 (PF1-OSC_OUT), X1.3
PA0: H2.16, U1.10 (PA0)
PA1: H2.15, U1.11 (PA1)
PA2: H2.14, U1.12 (PA2)
PA3: H2.13, U1.13 (PA3)
PA4: H2.12, U1.14 (PA4)
PA5: H2.11, U1.15 (PA5)
PA6: H2.10, U1.16 (PA6)
PA7: H2.9, U1.17 (PA7)
PA8: H3.16, U1.29 (PA8)
PA9: H3.15, U1.30 (PA9)
PA10: H3.14, U1.31 (PA10)
PA11: H3.13, U1.32 (PA11)
PA12: H3.12, U1.33 (PA12)
PA13/SWDIO: H4.3, U1.34 (PA13)
PA14/SWCLK: H4.2, U1.37 (PA14)
PA15: H3.11, U1.38 (PA15)
PB0: H2.8, U1.18 (PB0)
PB1: H2.7, U1.19 (PB1)
PB2: U1.20 (PB2)
PB3: H3.10, U1.39 (PB3)
PB4: H3.9, U1.40 (PB4)
PB5: H3.8, U1.41 (PB5)
PB6: H3.7, U1.42 (PB6)
PB7: H3.6, U1.43 (PB7)
PB8: H3.5, U1.45 (PB8)
PB9: H3.4, U1.46 (PB9)
PB10: H2.6, U1.21 (PB10)
PB11: H2.5, U1.22 (PB11)
PB12: H3.20, U1.25 (PB12)
PB13: H3.19, U1.26 (PB13)
PB14: H3.18, U1.27 (PB14)
PB15: H3.17, U1.28 (PB15)
PC13: H2.17, R5.1, U1.2 (PC13)
VBUS: C1.1, C2.1, H2.1, Q1.3 (VIN), USB1.2 (VBUS), USB1.11 (VBUS)
VMCU: C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, H1.1, H2.3, H2.20, H3.1, H4.4, Q1.2 (VOUT), R2.1, R4.2, U1.1 (VDD), U1.24 (VDD), U1.48 (VDD)
VREF_PIN: H2.19

Notes on the sheet:
主控电源滤波
SWD下载接口
CW32F030C8T6
Type-C供电/下载
拓展排针接口
晶振电路
通过跳线帽选择VMCU和 VREF_PIN
LDO-5V转3.3V电路
复位电路
BOOT模式选择
LED指示电路

Board: 2 copper layers, 70.0 x 35.0 mm, 34 parts (0 on the bottom side), 47 nets.

## KiCad design remote_fingers_ESP8266_check_kicadv807_2025-01-03/remote_fingers_ESP8266/project/remote_fingers_ESP8266.kicad_pcb

Parts:
C1, C3: 10uF; C_0805_2012Metric
C2, C6, C7: 100nF; C_0805_2012Metric
D1: 1N4007; D_SMA
J1: PINHD_1x2_Female; PinSocket_1x02_P2.00mm_Vertical
J2: PINHD_1x3_Male; PinHeader_1x03_P2.54mm_Vertical
J3: PINHD_1x5_Female; PinSocket_1x05_P2.54mm_Vertical
J4: PINHD_1x2_Female; PinSocket_1x02_P2.54mm_Vertical
Q1: AO3400A; SOT-23
R2, R3, R4, R5, R6: 10K; R_0805_2012Metric
SW1: SW_SPDT; SW_Slide_SPDT_Angled_CK_OS102011MA1Q
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: ESP-12F; ESP-12E

Connections:
+3.3V: C3.2, C6.2, R2.1, R3.2, R4.1, U1.2 (VO), U2.8 (VCC)
+BATT: J1.2, SW1.2 (B)
/#RST: R2.2, U2.1 (~RST)
/EN: R4.2, U2.3 (EN)
/GPIO0: J3.2, R3.1, U2.18 (GPIO0)
/GPIO4: J2.2, U2.19 (GPIO4)
/GPIO5: J4.1, U2.20 (GPIO5)
/RXD: J3.4, U2.21 (GPIO3/RXD)
/SERVOS_EN: Q1.1 (G), R5.2, U2.5 (GPIO14)
/TXD: J3.5, U2.22 (GPIO1/TXD)
GND: C1.1, C2.1, C3.1, C6.1, J1.1, J3.1, J3.3, J4.2, Q1.2 (S), R5.1, R6.2, U1.1 (GND), U2.15 (GND)
unnamed: C7.1, D1.2 (A), J2.3, Q1.3 (D)
unnamed: R6.1, U2.16 (GPIO15)
VBUS: C1.2, C2.2, C7.2, D1.1 (K), J2.1, SW1.3 (C), U1.3 (VI)

Notes on the sheet:
模组启动模式说明 模式 CH_PD(EN) RST GPIO15 GPIO0 GPIO2 TXD0 下载模式 高 高 低 低 高 高 运行模式 高 高 低 高 高 高
功率:1.2W,反向传输电容(Crss@Vds):70pF, 导通电阻(RDS(on)@Vgs,Id):27mΩ@4.5V,5A, 工作温度:-50℃~+150℃,栅极电荷(Qg@Vgs):17.3nC@10V, 漏源电压(Vdss):30V,类型:1个N沟道,输入电容(Ciss@Vds):632pF, 连续漏极电流(Id):5.8A,阈值电压(Vgs(th)@Id):1.5V@250uA
通过线连接到手指指尖。 指尖有一个微触开关。 可以感受到触碰到机器狗的开关。
短接 GPIO0与GND->下载模式， 不短接GPIO0与GND->运行模式。 USB转TTL下载器，连接TXD和RXD下载。
GPIO4使用PWM来做电机控制。
SERVOS_EN 上拉使能
锂电池软包，PH 1x2 2mm间距
滑动开关开机
ESP-12F耗电 2mA。 light sleep 2mA. led 3.3V /1K = 3.3mA 待机机5天，需要 5 day * 24 h * 5.3mA = 636mAh 所以1000mAh绰绰有余。
SG90 360度 额定电压4.8V 额定电流1A 扭矩1.2kg.cm

Board: 2 copper layers, 34.0 x 38.5 mm, 19 parts (0 on the bottom side), 14 nets.
