# Repository lessthan00/wsy_kicad

## KiCad design 100MHz_high_voltage_differential_probe_produce_hard_kicadv805_2024-10-26/100MHz_high_voltage_differential_probe.kicad_pcb

Parts:
BUZZER1: 3kHz; BUZ-TH_BD9.0-P5.00-D0.6-FD; Manufacturer Part HNB09A03; LCSC Part Name 电磁式有源一体蜂鸣器HNB09A03
C1, C2, C4, C5, C21, C22, C23, C24, C25, C26: 10uF; C0603
C3, C13, C14, C41, C42, C43, C44, C45, C46, C53, C54, C55, C56, C57, C58, C59, C60, C61, C62: 100nF; C0603
C6: 1nF; C1808; Manufacturer Part SCC1808X102K502T; LCSC Part Name 等级:X1,Y2 1nF ±10% 250V
C7, C8: 1nF; C0603
C9, C10, C11, C12, C15, C16, C17, C18, C19, C20: 22uF; C0603
C27, C28, C29, C30, C31, C32: 4.7pF/1KV; R1206
C33, C34: 2.2pF/1KV; R1206
C35, C36, C37, C38: 100pF; C0603
C39, C40: 120pF; CAP-TH_JML06
C47, C48, C49, C50, C51, C52: 1uF; C0603
C63: 820pF; C0603
C64: 220pF; C0603
C65: NC; C0603
C66: 22pF; C0603
C67: 100pF; R0402
C68: 47pF; R0402
C69: 2.2pF; C0603
D1: SOD-323_L1.7-W1.3-LS2.5-BI; Manufacturer Part PESD5V0S1BA; LCSC Part Name PESD5V0S1BA
D2: SOD-123_L2.7-W1.6-LS3.7-RD-1; Manufacturer Part B0520LW; LCSC Part Name 电压:20V 电流:500mA
D3, D4, D5, D6, D7: SOD-323_L1.8-W1.3-LS2.5-RD; Manufacturer Part B5819WS; LCSC Part Name 电压:40V 电流:1A
L1, L2, L3: FILTER-SMD_4P-L3.2-W2.5-TL_PCAQ3225A; Manufacturer Part WCM3225F2SF-601T10; LCSC Part Name 两路 贴片共模滤波器 阻抗600Ω@100MHz
L4, L5: 2kΩ@100MHz; L0603; Manufacturer Part GZ1608D202TF; LCSC Part Name 单路 0603磁珠 阻抗2kΩ@100MHz
LED1, LED5: BLUE; LED0603-R-RD
LED2: RED; LED0603-R-RD
LED3, LED4: GREEN; LED0603-R-RD
Q1, Q5: SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; Manufacturer Part SS8050-G; LCSC Part Name SS8050-G(RANGE:120-200) L档(120-200)
Q2, Q3, Q4: SOT-23_L2.9-W1.3-P1.90-LS2.4-BR; Manufacturer Part AO3401A; LCSC Part Name 1个P沟道 耐压:30V 电流:4.2A
Q6: SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; Manufacturer Part AD-SS8550; LCSC Part Name AD-SS8550
Q7: SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; Manufacturer Part TL432; LCSC Part Name 1.25V~18V 100mA SOT-23
R1, R2: 5.1KΩ; R0603
R3: 27KΩ; R0603
R4, R7: 4.7KΩ; R0603
R5, R6, R70, R72: 1KΩ; R0603
R8, R9: 100KΩ; R0603
R10: 47KΩ; R0603
R11, R12, R48, R49: 22Ω; R0603
R13, R14: 330Ω; R0603
R15, R16: 0Ω; R0603
R17, R19: 120KΩ; R0603
R18, R20: 110KΩ; R0603
R21, R22: 1kΩ; R1206
R23, R24, R25, R26, R27, R28, R29, R30: 1MΩ; R1206
R31, R35, R74: 7.5KΩ; R0603
R32, R34, R50, R51, R52, R53, R54, R55: 402Ω; R0603
R33, R44, R45, R60: 10kΩ; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L; Manufacturer Part 3296W-1-103; LCSC Part Name 10kΩ ±10%
R36: 330KΩ; R0603
R37: NC; R0603
R38, R39, R40, R41, R42, R43: 10Ω; R0603
R46, R47, R73: 10KΩ; R0603
R56: 50Ω; R0603
R57, R61: 10Ω; R0402
R58: 3.3kΩ; R0402
R59: 100Ω; R0402
R62, R63, R64, R65, R68, R69: 2.2KΩ; R0603
R66, R67: 200Ω; R0603
R71: 18KΩ; R0603
RF1: SMA-SMD_BWSMA-KE-P001; Manufacturer Part BWSMA-KE-P001; LCSC Part Name 内孔 SMA 偏脚
SW1, SW2: SW-TH_TK-6580-1; Manufacturer Part TK-6580-1; LCSC Part Name 自锁开关5.8*5.8*10有声有锁高导高柄插件双排6P按键开关带锁DIP六脚
U1: SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; Manufacturer Part TP4057-42-SOT26-R; LCSC Part Name TP4057 1%
U2: SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; Manufacturer Part VPS8702; LCSC Part Name 微功率隔离电源专用芯片 3V~6V输入 0.5A功率管
U3: EPC10; XFMR-SMD_8P-L10.8-W7.9-P2.00_EPC10
U4: SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part ME6211C25M5G-N; LCSC Part Name 输入6.5V 输出2.5V 300mA
U5: SOT-23-5_L2.9-W1.6-P0.95-LS2.8-BL; Manufacturer Part SGM2209-ADJXN5G/TR; LCSC Part Name SGM2209-ADJXN5G/TR
U6, U7: 2MM香蕉头母座
U8, U9, U10, U11: SOD-323_L1.8-W1.3-LS2.5-RD; Manufacturer Part 1N4148WS; LCSC Part Name 电压:75V 电流:150mA
U12, U16, U17: SC-70-6_L2.1-W1.3-P0.65-LS2.3-BR; Manufacturer Part BL1551B; LCSC Part Name 2.7Ω低压SPDT模拟开关
U13, U14, U15: SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BL; Manufacturer Part SGM8061XN5/TR; LCSC Part Name SGM8061XN5/TR
U18: OPTO-SMD-4_L4.4-W2.7-P1.27-LS7.0-BR; Manufacturer Part JC3H7; LCSC Part Name 光耦 3H7
USB1: TYPE-C-SMD_TYPE-C-31-M-16; Manufacturer Part TYPE-C-31-M-16; LCSC Part Name Type-C 母

Connections:
#69: C68.1, R59.2
+2.5V: C25.2, C43.2, C47.2, C49.2, C51.2, C53.2, C55.2, C57.2, C59.2, C61.2, R15.2, R17.1, R48.1, SW2.4, SW2.5, U8.1 (C), U10.2 (A), U12.5 (VCC), U13.5 (VCC), U14.5 (VCC), U15.5 (VCC), U16.5 (VCC), U17.5 (VCC)
+4.5V: C17.2, C19.2, C21.2, L4.2, R13.1, R69.1, R72.1, SW2.2, U4.1 (VIN), U4.3 (CE)
+5V: C4.2, C5.2, D2.1 (A), Q3.3 (D), Q4.2 (S), R3.1, R5.1, R8.2, R66.1, R67.1, R68.1, SW1.6, U2.1 (EN), U2.5 (VIN)
+VCC: C7.2, C9.2, C11.2, C13.2, D4.1 (K), D6.1 (K), L2.3
-2.5V: C26.2, C45.2, C48.2, C50.2, C52.2, C54.2, C56.2, C58.2, C60.2, C62.2, R16.2, R19.1, R49.1, R65.2, U9.2 (A), U11.1 (C), U12.2 (GND), U13.2 (VSS), U14.2 (VSS), U15.2 (VSS), U16.2 (GND), U17.2 (GND)
-4.5V: C18.2, C20.2, C22.2, L5.2, LED4.2 (K), LED5.2 (K), Q6.3 (C), R14.1, R71.2, U5.2 (VIN), U5.3 (EN)
-VCC: C8.2, C10.2, C12.2, C14.2, D5.2 (A), D7.2 (A), L3.2
/50X_BIAS_IN: R47.2, U12.3 (A2)
/500X_BIAS_IN: R46.2, U12.1 (A1)
/#1: R2.1, USB1.A5 (CC1)
/#2: R1.1, USB1.B5 (CC2)
/#3: Q1.1 (B), R3.2, R4.1
/#4: LED1.1 (A), R5.2
/#5: LED1.2 (K), Q1.3 (C)
/#6: LED2.1 (A), LED3.1 (A), R6.1
/#7: LED2.2 (K), U1.1 (CHRG#)
/#8: LED3.2 (K), U1.5 (STDBY#)
/#9: R7.1, U1.6 (PROG)
/#10: D3.1 (K), Q2.1 (G), Q3.1 (G), R9.2, SW1.2
/#11: Q2.2 (S), Q3.2 (S), R9.1
/#12: Q4.1 (G), R8.1, SW1.5
/#13: R10.1, SW1.3
/#14: U2.6 (VD1), U3.1
/#15: U2.4 (VD2), U3.2
/#16: D4.2 (A), D6.2 (A), R11.1, U3.8
/#17: D5.1 (K), D7.1 (K), R12.1, U3.5
/#18: C7.1, R11.2
/#19: C8.1, R12.2
/#20: C15.2, L2.4, L4.1
/#21: C16.2, L3.1, L5.1
/#22: C23.2, R15.1, U4.5 (VOUT)
/#23: R17.2, R18.1, U4.4 (NC)
/#24: C24.2, R16.1, U5.5 (VOUT)
/#25: R19.2, R20.1, U5.4 (NC)
/#26: R21.1, U6.1
/#27: R22.1, U7.1
/#28: C27.1, R21.2, R23.2
/#29: C28.1, R22.2, R24.2
/#30: C27.2, C29.1, R23.1, R25.2
/#31: C28.2, C30.1, R24.1, R26.2
/#32: C29.2, C31.1, R25.1, R27.2
/#33: C30.2, C32.1, R26.1, R28.2
/#34: C31.2, C33.1, R27.1, R29.2
/#35: C32.2, C34.1, R28.1, R30.2
/#36: R31.2, R32.1
/#37: R34.1, R35.2
/#38: R32.2, R33.3
/#39: R33.1, R34.2
/#40: C35.2, R38.1
/#41: C36.2, R39.1
/#42: C37.2, R40.1
/#43: C38.2, R41.1
/#44: C39.2, R42.1
/#45: C40.2, R43.1
/#46: C41.2, R44.2, R46.1
/#47: C42.2, R45.2, R47.1
/#48: C63.1, R50.1, R52.2, U13.1 (OUT)
/#49: C64.1, R51.1, R53.2, U14.1 (OUT)
/#50: R52.1, R54.1, U15.3 (IN+)
/#51: C65.2, R53.1, R55.2, U15.4 (IN-)
/#52: C65.1, C66.2, R55.1, R56.2, U15.1 (OUT)
/#53: C67.1, R57.2, R58.1, R59.1, R60.3
/#54: C67.2, C68.2, R58.2, R60.1, R60.2, R61.1
/#55: LED4.1 (A), R62.1
/#56: LED5.1 (A), R63.1
/#57: R62.2, SW2.1
/#58: R63.2, SW2.3
/#59: R64.1, SW2.6
/#60: BUZZER1.1 (+), R66.2, R67.2
/#61: BUZZER1.2 (-), Q5.3 (C), R68.2, U18.4
/#62: Q5.1 (B), U18.3
/#63: R69.2, U18.1
/#64: Q6.2 (E), U18.2
/#65: Q6.1 (B), R70.2, R71.1
/#66: Q7.2 (K), R70.1, R72.2
/#67: C69.1, Q7.1 (R), R73.1, R74.1
/BIAS_OUT: R36.1, U12.4 (B)
/HV_IN+: C34.2, C36.1, C38.1, C40.1, R30.1, R35.1, R37.2, U10.1 (C), U11.2 (A), U13.3 (IN+)
/HV_IN-: C33.2, C35.1, C37.1, C39.1, R29.1, R31.1, R36.2, U8.2 (A), U9.1 (C), U14.3 (IN+)
/SET_EN: R64.2, R65.1, U12.6 (ENB), U16.6 (ENB), U17.6 (ENB)
/SIGNAL_A: C63.2, R50.2, U13.4 (IN-), U17.4 (B)
/SIGNAL_B: R57.1, U17.3 (A2)
/SIGNAL_C: R61.2, U16.4 (B)
/SIGNAL_D: C64.2, R51.2, U14.4 (IN-), U16.3 (A2)
/SIGNAL_OUT: C66.1, R56.1, R74.2, RF1.5
BAT+: C3.2, Q2.3 (D), U1.3 (BAT)
BAT_CHRG: Q4.3 (D), R6.2, U1.4 (VCC)
EGND: C1.1, D1.2, L1.3, R1.2, R2.2, USB1.1, USB1.2, USB1.3, USB1.4, USB1.A12 (GND), USB1.B12 (GND)
GND: C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C69.2, L2.1, L3.4, Q7.3 (A), R13.2, R14.2, R18.2, R20.2, R33.2, R37.1, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R54.2, R73.2, RF1.1, RF1.2, RF1.3, RF1.4, U4.2 (VSS), U5.1 (GND)
PGND: C2.1, C3.1, C4.1, C5.1, C6.2, L1.4, Q1.2 (E), Q5.2 (E), R4.2, R7.2, R10.2, SW1.4, U1.2 (GND), U2.2 (GND), U3.4
POWER_IN: C1.2, D1.1, L1.2, USB1.A9 (VBUS), USB1.B9 (VBUS)
SGND: C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, L2.2, L3.3, U3.6, U3.7
VBUS: C2.2, D2.2 (K), D3.2 (A), L1.1
VCC_BIAS: C44.2, R44.3, R45.3, R48.2
VSS_BIAS: C46.2, R44.1, R45.1, R49.2

Notes on the sheet:
UP=250X DOWN=500x
输出偏置微调
路径切换
衰减电路
关机 允许边充边用 开机 只允许使用，不充电
稳压与滤波电路
滤波电容
1/500 Gain
G=1
电池充电
500X
放大电路
250X
差分转单端
隔离变换
G=10时，R50=100Ω G=2.5时，R50=3.3kΩ R57=20K，C34=100pF，C70=47pF R84=100Ω，R85=10Ω，R86=10Ω， 由于10X衰减带宽低，现改为两档衰减 250X与500X 250X衰减，带宽约80MHz 由于压摆率限制，降调整为250X放大
超幅检测与告警电路
档位切换与指示电路
TYPE C供电接口

Board: 4 copper layers, 100.0 x 35.0 mm, 190 parts (0 on the bottom side), 96 nets.

## KiCad design DCDC_power_24V-12V-5V_useless_kicadv805_2024-10-26/projcet/DCDC_power_24V-12V-5V.kicad_pcb

Parts:
C1, C2: 22uF/X7R; C1206
C3, C5, C10: 100nF/X7R; C0805
C4: 2.7nF/X7R; C0805
C6, C7, C8, C9, C11, C12, C15, C16, C17: 22uF/X7R; C0805
C13, C18: 100nF; C0603
C14: 22nF; C0603
H1, H2, H3: HDR-TH_6P-P2.54-V-F-R2-C3-S2.54
L1: 15uH; IND-SMD_L10.8-W10.0_SLO1040H; Manufacturer Part SLO1040H150MTT; LCSC Part Name 15uH ±20%
L2: 15uH; IND-SMD_L11.5-W10.0_FXL1040; Manufacturer Part FXL1040-150-M; LCSC Part Name 15uH ±20% 7A
R1: 47kΩ; R0805
R2: 100kΩ; R0805
R3: 137kΩ; R0805
R4: 70kΩ 1%; R0805
R5: 5kΩ 1%; R0805
R6: NC; R0603
R7: 100KΩ; R0603
R8: 147kΩ 1%; R0603
R9: 20kΩ 1%; R0603
U1: SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL-EP2.0; Manufacturer Part RT7272BGSP; LCSC Part Name RT7272BGSP
U2: SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; Manufacturer Part MT2492; LCSC Part Name MT2492

Connections:
+5V: C15.2, C16.2, C17.2, C18.2, H3.2, H3.4, H3.6, L2.2, R8.2
+12V: C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, H2.2, H2.4, H2.6, L1.2, R4.2, R7.1, U2.5 (IN)
+24V: C1.1, C2.1, C3.2, H1.2, H1.4, H1.6, R2.1, U1.8 (VIN)
/1: C4.1, R1.2
/MT2492_BS: C14.2, U2.1 (BS)
/MT2492_EN: R6.2, R7.2, U2.4 (EN)
/MT2492_FB: R8.1, R9.2, U2.3 (FB)
/MT2492_SW: C14.1, L2.1, U2.6 (SW)
/RT7272_BOOT: C5.2, U1.2 (BOOT)
/RT7272_COMP: C4.2, U1.6 (COMP)
/RT7272_EN: R2.2, U1.3 (EN)
/RT7272_FB: R4.1, R5.2, U1.5 (FB)
/RT7272_RLIM: R3.2, U1.7 (RLIM)
/RT7272_SW: C5.1, L1.1, U1.1 (SW)
GND: C1.2, C2.2, C3.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, H1.1, H1.3, H1.5, H2.1, H2.3, H2.5, H3.1, H3.3, H3.5, R1.1, R3.1, R5.1, R6.1, R9.1, U1.4 (GND), U1.9 (EPAD), U2.2 (GND)

Board: 2 copper layers, 56.1 x 26.3 mm, 33 parts (0 on the bottom side), 15 nets.

## KiCad design LED_SMT_5730_5S2P_5W_useless_kicadv805_2024-10-26/project/LED_SMT_5730_5S2P_5W.kicad_pcb

Parts:
H1: M3
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10: LED_SMD_5730; LED-SMD_3P-L5.7-W3.0-RD; Manufacturer Part XL-5730WWC-05; LCSC Part Name XL-5730WWC-05

Connections:
GND: H1.1, LED5.1 (K), LED10.1 (K)
unnamed: LED1.1 (K), LED2.2 (A), LED2.3 (NC)
unnamed: LED2.1 (K), LED3.2 (A), LED3.3 (NC)
unnamed: LED3.1 (K), LED4.2 (A), LED4.3 (NC)
unnamed: LED4.1 (K), LED5.2 (A), LED5.3 (NC)
unnamed: LED6.1 (K), LED7.2 (A), LED7.3 (NC)
unnamed: LED7.1 (K), LED8.2 (A), LED8.3 (NC)
unnamed: LED8.1 (K), LED9.2 (A), LED9.3 (NC)
unnamed: LED9.1 (K), LED10.2 (A), LED10.3 (NC)
VLED1: LED1.2 (A), LED1.3 (NC), LED6.2 (A), LED6.3 (NC)

Board: 2 copper layers, 20.0 x 30.0 mm, 11 parts (0 on the bottom side), 10 nets.

## KiCad design PY32F002AW15S_mini_system_kicadv805_success_kicadv806_2024-11-16/PY32F002AW15S_mini_system_kicadv805/project/PY32F002AW15S_mini_system.kicad_pcb

Parts:
C1, C4: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C5, C6, C9, C10: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 100nF; C_0805_2012Metric; not fitted
C7, C8: 30pF; C_Disc_D5.1mm_W3.2mm_P5.00mm
J1: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3, J5: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
LED1: 红灯; LED_D3.0mm
LED2: 绿灯; LED_D3.0mm
R1, R2: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3, R4: 5.1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R6: 10kΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1, SW2: SW_DIP_x01; SW_PUSH_6mm_H7.3mm
U1: AZ1117IH-3.3TRE1; SOT-223-3_TabPin2
U2: PY32F002AW15S6TU; SOP-16_3.9x9.9mm_P1.27mm
X1: 12MHz_±20ppm_20pF_HC-49S; Crystal_HC49-U-3Pin_Vertical_change

Connections:
/NRST: C10.1, J5.10, R5.2, SW1.1, U2.8 (PF2-NRST)
/OSC+: C7.1, J3.9, U2.9 (PF0-OSCIN), X1.1
/OSC-: C8.1, J3.10, U2.10 (PF1-OSCOUT), X1.3
/PA0: J3.8, U2.11 (PA0)
/PA1: J3.7, U2.12 (PA1)
/PA2: J3.5, U2.14 (PA2)
/PA3: J3.4, U2.15 (PA3)
/PA6: J3.3, U2.16 (PA6)
/PA7: J5.3, U2.1 (PA7)
/PA9: J5.7, R2.1, U2.5 (PA9)
/PB0: J5.4, U2.2 (PB0)
/PB1: J5.5, U2.3 (PB1)
/SWCLK: J2.3, J5.9, U2.7 (PA14-SWC)
/SWDIO: J2.2, J5.8, U2.6 (PA13-SWD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, J3.2, J3.6, J5.2, LED1.1 (K), LED2.1 (K), R3.1, R4.1, SW1.2, SW2.2, U1.1, U2.13 (VSS), X1.2
unnamed: J1.A5 (CC1), R4.2
unnamed: J1.B5 (CC2), R3.2
unnamed: LED1.2 (A), R1.2
unnamed: LED2.2 (A), R2.2
unnamed: R6.2, SW2.1
VBUS: C1.1, C2.1, C3.1, J1.A9 (VBUS), J1.B9 (VBUS), U1.3 (IN)
VCC: C4.1, C5.1, C6.1, C9.1, J2.1, J3.1, J5.1, J5.6, R1.1, R5.1, R6.1, U1.2 (OUT), U2.4 (VCC)

Notes on the sheet:
匹配电容不合适，会导致频偏 CL=（CL1//CL2）+CS 即：CL=[（CL1xCL2）/（CL1+CL2）]+CS CL 晶振固有的负载电容， CS 杂散电容，约3pF-7pF CL1 CL2 负载电容 CL = 20pF， CL1 = CL2 = （20pF - 5pF）* 2 = 30pF
