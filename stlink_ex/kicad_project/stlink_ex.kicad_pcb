# Repository lessthan00/wsy_kicad

## KiCad design stlink_ex/kicad_project/stlink_ex.kicad_pcb

File stlink_ex/README.md:

# 这是ST-LINK的转接板
JTGA 和SWD

1.27mm间距和2.54mm间距

Board: 2 copper layers, 70.0 x 30.8 mm, 5 parts (0 on the bottom side), 7 nets.

Parts:
J5: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J10: PINHD_1x5_Female; FPC_5
J11: PINHD_1x5_Male; PinHeader_1x05_P2.54mm_Vertical
J14: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J15: Conn_02x05_Odd_Even; FPC_2x5

Connections:
/GND: J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J5.18, J5.20, J10.4, J11.4, J14.3, J14.5, J14.7, J14.9, J15.3, J15.5, J15.7, J15.9
/JTCK: J5.9, J10.2, J11.2, J14.4, J15.4
/JTDI: J5.5, J14.8, J15.8
/JTDO: J5.13, J14.6, J15.6
/JTMS: J5.7, J10.3, J11.3, J14.2, J15.2
/MCU VDD: J5.1, J5.2, J10.1, J11.1, J14.1, J15.1
/NRST: J5.15, J10.5, J11.5, J14.10, J15.10

## KiCad design LED_SMT_5730_5S6P_15W_produce_kicadv805_2024-10-26/LED_SMT_5730_5S6P_15W/project/LED_SMT_5730_5S6P_15W.kicad_pcb

Parts:
H1: MountingHole_3mm_Pad
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30: LED_PLCC2_5.7x3.0_Pad; LED_Yuji_5730; Manufacturer Part XL-5730WWC-05; LCSC Part Name XL-5730WWC-05

Connections:
GND: LED5.2 (A), LED10.2 (A), LED15.2 (A), LED20.2 (A), LED25.2 (A), LED30.2 (A)
unnamed: LED1.2 (A), LED2.1 (K), LED2.3 (PAD)
unnamed: LED2.2 (A), LED3.1 (K), LED3.3 (PAD)
unnamed: LED3.2 (A), LED4.1 (K), LED4.3 (PAD)
unnamed: LED4.2 (A), LED5.1 (K), LED5.3 (PAD)
unnamed: LED6.2 (A), LED7.1 (K), LED7.3 (PAD)
unnamed: LED7.2 (A), LED8.1 (K), LED8.3 (PAD)
unnamed: LED8.2 (A), LED9.1 (K), LED9.3 (PAD)
unnamed: LED9.2 (A), LED10.1 (K), LED10.3 (PAD)
unnamed: LED11.2 (A), LED12.1 (K), LED12.3 (PAD)
unnamed: LED12.2 (A), LED13.1 (K), LED13.3 (PAD)
unnamed: LED13.2 (A), LED14.1 (K), LED14.3 (PAD)
unnamed: LED14.2 (A), LED15.1 (K), LED15.3 (PAD)
unnamed: LED16.2 (A), LED17.1 (K), LED17.3 (PAD)
unnamed: LED17.2 (A), LED18.1 (K), LED18.3 (PAD)
unnamed: LED18.2 (A), LED19.1 (K), LED19.3 (PAD)
unnamed: LED19.2 (A), LED20.1 (K), LED20.3 (PAD)
unnamed: LED21.2 (A), LED22.1 (K), LED22.3 (PAD)
unnamed: LED22.2 (A), LED23.1 (K), LED23.3 (PAD)
unnamed: LED23.2 (A), LED24.1 (K), LED24.3 (PAD)
unnamed: LED24.2 (A), LED25.1 (K), LED25.3 (PAD)
unnamed: LED26.2 (A), LED27.1 (K), LED27.3 (PAD)
unnamed: LED27.2 (A), LED28.1 (K), LED28.3 (PAD)
unnamed: LED28.2 (A), LED29.1 (K), LED29.3 (PAD)
unnamed: LED29.2 (A), LED30.1 (K), LED30.3 (PAD)
VLED1: LED1.1 (K), LED1.3 (PAD), LED6.1 (K), LED6.3 (PAD), LED11.1 (K), LED11.3 (PAD)
VLED2: LED16.1 (K), LED16.3 (PAD), LED21.1 (K), LED21.3 (PAD), LED26.1 (K), LED26.3 (PAD)

Notes on the sheet:
x 5730LED 正白参数 正向工作电流 150mA 光强 60mcd 主波长 3200nm 正向电压 3.2V-3.4V 5串6并供电电压16V-17V 工作电流 900mA 功率 14.85W 两节18650锂电池供电

Board: 2 copper layers, 40.0 x 50.0 mm, 31 parts (0 on the bottom side), 27 nets.

## KiCad design Raindrop_humidity_sensing_board_useless_kicadv805_2024-10-26/project/Raindrop_humidity_sensing_board.kicad_pcb

Board: 2 copper layers, 32.0 x 15.0 mm, 12 parts (0 on the bottom side), 7 nets.

Parts:
C1, C2: 100nF/X7R; C0805
H1: HDR-TH_2P-P2.54-V-F
H2: HDR-TH_4P-P2.54-V-F
LED1, LED2: LED0603-R-RD
R1, R3: 10KΩ; R0805
R2: 10kΩ; RES-ADJ-TH_3P-L10.0-W10.0-P2.50-L
R4, R5: 1KΩ; R0805
U1: SOIC-8_L5.0-W4.0-P1.27-LS6.0-BL

Connections:
/LED2_K: LED2.1 (A), R5.1
/LED3_K: LED1.1 (A), R4.1
/LM393_INAN: R2.2, U1.2 (INAN)
/LM393_INAP: C1.2, H1.1, H2.4, R1.1, U1.3 (INAP)
/LM393_OUTA: H2.3, LED1.2 (K), R3.1, U1.1 (OUTA)
GND: C1.1, C2.1, H1.2, H2.2, LED2.2 (K), R2.1, U1.4 (GND)
VCC: C2.2, H2.1, R1.2, R2.3, R3.2, R4.2, R5.2, U1.8 (VCC)

## KiCad design AMS1117_TP4056_Lithium_battery_charging/project/AMS1117_TP4056_Lithium_battery_charging.kicad_pcb

File AMS1117_TP4056_Lithium_battery_charging/README.md:

3.7V锂电池充电模板，用来给单节锂电池冲电，或集成在其它产品上，用来做冲电主控使用。

## TP4056主要参数

1.可编程充电电流1000mA.
2.恒定电流/恒定电压操作，并具有可在无过热危险 的情况下实现充电速率最大化的热调节功能。
3精度达到±1%的4.2V预充电电压.
4.充电状态双输出、无电池和故障状态显示。

##  描述

## TP4056主要参数

1.可编程充电电流1000mA.
2.恒定电流/恒定电压操作，并具有可在无过热危险 的情况下实现充电速率最大化的热调节功能。
3精度达到±1%的4.2V预充电电压.
4.充电状态双输出、无电池和故障状态显示。

## 主要用应于

1.可用于单节锂电池冲电。
2.便携式设备。
3.充电器。
4.蓝牙、GPS导航仪等。

## 各引脚功能说明

管 脚 号 管 脚 名 描 述
1     TEMP        电池温度检测输入
2     PROG       可编程恒流充电电流设置端
3     GND        地端
4     VCC         电源端
5     BAT         电池端
6     STDBY       电池充电完成指示端
7     CHRG       电池充电指示端
8     CE          芯片使能输入端

### 输出电流计算

电路中不同的输出电流是能过第9脚来决定的。设定电阻器和充电电流采用下列公式来计算：
R PROG=1200/Ibat（误差±10％）
最小能输出100mA的电流，最大能输出1A的电流。

### 状态指示说明

TP4056有两个漏极开路状态指示输出端CHRG和STDBY。当充电器处于充电状态时，CHRG被拉到低电平，在其他状态
CHRG为高阻态；当电池充电结束后，STDBY被拉到低电平，在其他状态STDBY为高阻态。
当电池没有接到充电器时，CHRG闪烁表示没有安装电池。

### 指示灯亮灭表：

充电状态                                 		CHRG             STDBY
正在充电                                   		亮                 灭
充电完成                                   		灭                 亮
欠压，电池温度过高，过低                    灭                 灭
等故障状态,或无电池接入(TEMP使用)
BAT端连接1uF电容，无电池              闪烁（频率约20Hz）       亮

### 温度检测

此电路中没有使用温度检测功能，所以第1脚直接做了接地处理，如需要使用温度检测，请参考数据手册。

check_kicadv805_2024-10-29

Parts:
C1, C4, C7, C9: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C5, C8, C10: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3, C6: 100nF; C_0805_2012Metric; not fitted
H1: MountingHole_3mm_Pad
LED1: 红灯; LED_D3.0mm
LED2: 绿灯; LED_D3.0mm
P1, P2: Screw_Terminal_2_P5.00mm; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
R1: 1.2KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R5: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: TP4056_ESOP-8; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias2
U2: AMS1117-5.0; SOT-223-3_TabPin2

Connections:
BAT: C1.1, C2.1, C3.1, P1.2, U1.5 (BAT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, H1.1, P1.1, P2.2, R1.1, U1.1 (TEMP), U1.3 (GND), U1.9 (EP), U2.1 (GND)
unnamed: LED1.2 (A), R2.2
unnamed: LED1.1 (K), U1.7 (CHRG#)
unnamed: LED2.2 (A), R5.2
unnamed: LED2.1 (K), U1.6 (STDBY#)
unnamed: R1.2, U1.2 (PROG)
VCC: C4.1, C5.1, C6.1, C9.1, C10.1, R2.1, R5.1, U1.4 (VCC), U1.8 (CE), U2.2 (VO)
VIN: C7.1, C8.1, P2.1, U2.3 (VI)

Notes on the sheet:
锂电池充电电路 STDBY_充电完成指示端 CHRG_充电指示端 PROG_可编程恒流充电电流设置端 TEMP_电池温度检测输入

Board: 2 copper layers, 35.0 x 35.0 mm, 20 parts (4 on the bottom side), 9 nets.

## KiCad design feed_cat_water_kicadv805/project/feed_cat_water.kicad_pcb

Parts:
C1, C4, C6, C9, C18: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C5, C7, C8, C10, C12, C13, C17, C19, C20, C22: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 220uF; CP_Radial_D8.0mm_P3.50mm
C11: 100nF; C_0805_2012Metric; not fitted
C14: 100uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C15, C21, C23: 10nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C16: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm; not fitted
C24: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm; not fitted
D1: 1N4148; D_DO-35_SOD27_P3.81mm_Vertical_KathodeUp
DZ1: 1N4735A; D_DO-41_SOD81_P3.81mm_Vertical_KathodeUp
H1, H2: MountingHole_3mm_Pad
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: Screw_Terminal_2_P5.00mm; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
J3, J4: Screw_Terminal_3_P5.00mm; TerminalBlock_Phoenix_PT-1,5-3-5.0-H_1x03_P5.00mm_Horizontal
LED1: 红灯; LED_D3.0mm
P1: Screw_Terminal_2_P5.00mm; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
Q1: Si2302CDS; SOT-23
R1: 1.2KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3: 5.1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 10kΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R10: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R11, R15, R16, R17: 100KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R8: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
R9: 1MΩ？; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R12: 1KΩ?; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13: 47KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R14: 1MΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R18: 47KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical; not fitted
S1: D203S_TO-5-3; TO-5-3; Manufacturer Part D203S; LCSC Part Name 热释电红外线传感器
SW1: SW_DIP_x01; SW_PUSH_6mm_H7.3mm
U1: AZ1117IH-3.3TRE1; SOT-223-3_TabPin2
U2: TP4056_ESOP-8; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias2
U3: PY32F002AW15S6TU; SOP-16_3.9x9.9mm_P1.27mm
U4: LM324; SOIC-14_3.9x8.7mm_P1.27mm
USB1: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal

Connections:
/DOUT: J4.2, U4.1, U4.14
/NRST: C13.1, R4.2, SW1.1, U3.8 (PF2-NRST)
/PA0: U2.7 (CHRG#), U3.11 (PA0)
/PA1: U2.6 (STDBY#), U3.12 (PA1)
/PA2: U3.14 (PA2)
/PA3: U3.15 (PA3)
/PA6: U3.16 (PA6)
/PA7: DZ1.1 (K), Q1.1 (G), R6.1, U3.1 (PA7)
/PA9: R5.1, U3.5 (PA9)
/PB0: U3.2 (PB0)
/PB1: J3.2, U3.3 (PB1)
/PF0: U3.9 (PF0-OSCIN)
/PF1: U3.10 (PF1-OSCOUT)
/SWCLK: J1.2, U3.7 (PA14-SWC)
/SWDIO: J1.3, U3.6 (PA13-SWD)
BAT: C1.1, C2.1, C3.1, C4.1, C5.1, P1.2, Q1.3 (D), U1.3 (IN), U2.5 (BAT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C19.2, C20.2, C22.2, C24.2, D1.2 (A), H1.1, H2.1, J1.4, J2.2, J3.3, J4.3, LED1.1 (K), P1.1, R1.1, R2.1, R3.1, R13.2, R15.2, R17.2, S1.1 (D), SW1.2, U1.1, U2.1 (TEMP), U2.3 (GND), U2.9 (EP), U3.13 (VSS), U4.11 (V-), USB1.A12 (GND), USB1.B12 (GND), USB1.S1 (SHIELD)
unnamed: C18.1, C23.2, R14.2, U4.7
unnamed: C18.2, R12.2
unnamed: C24.1, R18.1
unnamed: C14.1, D1.1 (K), DZ1.2 (A), J2.1, Q1.2 (S), R6.2
unnamed: LED1.2 (A), R5.2
unnamed: C17.1, R8.2, S1.3 (G)
unnamed: C20.1, R10.2, R13.1, S1.2 (S)
unnamed: R1.2, U2.2 (PROG)
unnamed: C15.2, R9.2, U4.3 (+), U4.8, U4.13 (-)
unnamed: R7.2, R11.1, U4.2 (-)
unnamed: C21.1, R10.1, U4.5 (+)
unnamed: C21.2, C23.1, R14.1, R18.2, U4.6 (-)
unnamed: C22.1, R16.1, R17.1, U4.10 (+)
unnamed: C15.1, R9.1, R12.1, U4.9 (-)
unnamed: R11.2, R15.1, U4.12 (+)
unnamed: R3.2, USB1.A5 (CC1)
unnamed: R2.2, USB1.B5 (CC2)
VBUS: C9.1, C10.1, C11.1, U2.4 (VCC), U2.8 (CE), USB1.A9 (VBUS), USB1.B9 (VBUS)
VCC: C6.1, C7.1, C8.1, C12.1, C16.1, C19.1, J1.1, J3.1, J4.1, R4.1, R7.1, R8.1, R16.2, U1.2 (OUT), U3.4 (VCC), U4.4 (V+)

Notes on the sheet:
DOUT链接PB1
到电机，电机3.7V,1A
接锂电池
TIM1_CH2(PA9)
最小电压增益85
高电平时有生物，低电平时无生物。
1.5V虚地 单电源工作的运放需要外部提供一个虚地，通常情况下， 这个电压是VCC/2，可以用来产生VCC/2的电压，但是他会降低系统的低频特性
RC吸收
反比例放大，放大倍率-(RF/R) = 1000 需要调试。
锂电池充电电路 STDBY_充电完成指示端 CHRG_充电指示端 PROG_可编程恒流充电电流设置端 TEMP_电池温度检测输入
低通滤波器，用来减少从电源上传来的噪声
作用：主要是用来滤波的，让我们的电源网络更加干净，抑制干扰信号。 取值：一般取值为103，104和105。主要是根据运放的工作频率来决定，一般频率越高，电容就越 小，反之则大。
吸收电机尖峰脉冲
充电电流1A
电压跟随器，用作阻抗变换
作用：抗干扰作用。 怎么理解。假设同相输入端有一个瞬间的很高干扰信号进来，那么同相输入端就高于反相输入端， 输出端一瞬间就会产生一个干扰信号，但由于电容的存在，输出端就会很快的通过电容反馈到反相输入 端，这是因为电容两端的电压不能突变，那么信号就会完整的加到反相输入端。两个正负输入端就会互 相抵消。 取值：一般都是几PF到几十PF。
电机断电时续流以保护电机，减少尖峰脉冲
Π形滤波
电容，充电需要时间，这样保持一定时间的下拉
红灯常亮，代表充电 红灯不亮，代表充满 红灯慢闪烁，代表电量低 红灯快闪烁，代表需要更换滤芯。
NMOS，G级上拉导通，作为开关，2.6A
1、频率补偿电容，弥补输入电容带来的响应延迟，抑制运放自激振荡。 2、滤波，滤除高频干扰信号，防止对后级电路产生干扰。 取值:一般为几十PF。
板子是不能画在一个上的，那样不好做外壳
交流耦合，有效信号大约1mV,为变化的
6.2V稳压，保护NMOS
ADC_IN9(PB1)
保护电池免受电机的冲击
下拉电阻，保证上电瞬间NMOS处于关断状态

Board: 2 copper layers, 109.6 x 40.0 mm, 60 parts (7 on the bottom side), 30 nets.

## KiCad design LED5730_10pcs_1.5A_3.5V_check_kicadv806_2024-11-11/LED5730_10pcs_1.5A_3.5V/project/LED5730_10pcs_1.5A_3.5V.kicad_pcb

Parts:
H1, H2: MountingHole_Pad; MountingHole_3mm_Pad
J1, J2: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20: LED_PLCC2_5.7x3.0_Pad; LED_Yuji_5730
Q1, Q2: Si2302CDS; SOT-23
R1, R3: 51KΩ?; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R4: GL5506; R_LDR_5.1x4.3mm_P3.4mm_Vertical

Connections:
+2.7V~4.2V: J1.1, J2.1, LED1.1 (K), LED2.1 (K), LED3.1 (K), LED4.1 (K), LED5.1 (K), LED6.1 (K), LED7.1 (K), LED8.1 (K), LED9.1 (K), LED10.1 (K), LED11.2 (A), LED11.3 (PAD), LED12.2 (A), LED12.3 (PAD), LED13.2 (A), LED13.3 (PAD), LED14.2 (A), LED14.3 (PAD), LED15.2 (A), LED15.3 (PAD), LED16.2 (A), LED16.3 (PAD), LED17.2 (A), LED17.3 (PAD), LED18.2 (A), LED18.3 (PAD), LED19.2 (A), LED19.3 (PAD), LED20.2 (A), LED20.3 (PAD)
GND: H1.1, H2.1, J1.2, J2.2, Q1.2 (S), Q2.2 (S), R2.2, R4.2
unnamed: LED1.2 (A), LED1.3 (PAD), LED2.2 (A), LED2.3 (PAD), LED3.2 (A), LED3.3 (PAD), LED4.2 (A), LED4.3 (PAD), LED5.2 (A), LED5.3 (PAD), LED6.2 (A), LED6.3 (PAD), LED7.2 (A), LED7.3 (PAD), LED8.2 (A), LED8.3 (PAD), LED9.2 (A), LED9.3 (PAD), LED10.2 (A), LED10.3 (PAD), Q1.3 (D), R1.1
unnamed: LED11.1 (K), LED12.1 (K), LED13.1 (K), LED14.1 (K), LED15.1 (K), LED16.1 (K), LED17.1 (K), LED18.1 (K), LED19.1 (K), LED20.1 (K), Q2.3 (D), R3.1
unnamed: Q1.1 (G), R1.2, R2.1
unnamed: Q2.1 (G), R3.2, R4.1

Notes on the sheet:
LED的pad连GND
LED的pad连VCC

Board: 2 copper layers, 90.0 x 40.0 mm, 30 parts (0 on the bottom side), 6 nets.

## KiCad design BISS0001_SOP-16_TH_success_kicadv805_2024-10-26/BISS0001_SOP-16_TH/project/BISS0001_SOP-16_TH.kicad_pcb

Parts:
C1, C3, C10: 10nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C11, C12: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C5, C6, C9: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
H1, H3: PinHeader_1x03_P2.54mm_Vertical
H2: MountingHole_3mm_Pad
PR1, PR2: 10KΩ; Potentiometer_Bourns_3296W_Vertical; Manufacturer Part RM065-203(20K); LCSC Part Name 20kΩ ±25%
R1, R8: 1MΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 3.3KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 2MΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 33KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5: 1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6, R7: 47KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9: R_Photo; R_LDR_5.1x4.3mm_P3.4mm_Vertical; Manufacturer Part GL5506（4-7K）; LCSC Part Name 亮电阻:4kΩ~7kΩ 暗电阻:500kΩ
S1: D203S_TO-5-3; TO-5-3; Manufacturer Part D203S; LCSC Part Name 热释电红外线传感器
U1: BISS0001_SOP-16; SOP-16_3.9x9.9mm_P1.27mm; Manufacturer Part BISS0001; LCSC Part Name BISS0001

Connections:
3V3: C5.2, C9.2, H1.3, H3.3, R4.2, S1.1 (D), U1.11 (VDD)
GND: C5.1, C6.1, C9.1, C10.1, C11.1, C12.1, H1.1, H2.1, H3.1, R6.1, R8.1, R9.2, S1.3 (G), U1.7 (VSS), U1.8 (VRF/RESET)
unnamed: C2.2, R2.1
unnamed: C12.2, R7.1
unnamed: H1.2, U1.1 (A)
unnamed: H3.2, R5.1
unnamed: C10.2, R6.2, S1.2 (S), U1.14 (1IN+)
unnamed: C3.2, R3.1, R7.2, U1.15 (1IN-)
unnamed: C2.1, C3.1, R3.2, U1.16 (1OUT)
unnamed: C1.1, R1.2, R2.2, U1.13 (2IN-)
unnamed: C1.2, R1.1, U1.12 (2OUT)
unnamed: R8.2, U1.10 (IB)
unnamed: C6.2, PR1.1, PR1.2, U1.4 (RC1)
unnamed: C11.2, PR2.2, PR2.3, U1.5 (RC2)
unnamed: PR1.3, U1.3 (RR1)
unnamed: PR2.1, U1.6 (RR2)
unnamed: R4.1, R9.1, U1.9 (VC)
unnamed: R5.2, U1.2 (VO)

Notes on the sheet:
Ti≈48×R9×C7 =48 * 10K * 10 * 10^-6 =4.8s
从数据手册获得的原理图
Tx≈49152×R10×C6 =49152 * 10K * 100 * 10^-9 = 49s
引脚1 A 可重复触发和不可重复触发控制端。当 A="1"时，允许重复触发，当A="0"时，不可重复触发 引脚2 VO 控制信号输出端。由 VS 上跳边沿触发使 V0 从低电平跳变到高电平时为有效触发。在输出延迟时间 TX 之外和无 VS 上跳变时 V0 为低电平状态 引脚8 VREF 参考电压及复位输入端。一般接 VDD。接"0"时可使定时器复位。 引脚9 VC 触发禁止端。当 VC<VR 时禁止触发,当 VC>VR 时允许触发。VR≈0.2VDD 引脚10 IB 运算放大器偏置电流设置端。经 RS 接 VSS，RS 取值为 1MΩ左右 供电 VDD typ 3.3V, max 5V 引脚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
