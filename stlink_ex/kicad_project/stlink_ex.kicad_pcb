# Repository lessthan00/wsy_kicad (continued)

## KiCad design BISS0001_SOP-16_TH_success_kicadv805_2024-10-26/BISS0001_SOP-16_TH/project/BISS0001_SOP-16_TH.kicad_pcb (continued)

Board: 2 copper layers, 29.0 x 41.0 mm, 25 parts (3 on the bottom side), 18 nets.

File BISS0001_SOP-16_TH_success_kicadv805_2024-10-26/BISS0001_SOP-16_TH/product/BISS0001_SOP-16_TH_BOM_utf-8.csv:

"Reference","Value","Footprint","Qty","DNP","Manufacturer Part","Supplier Part"
"C1,C3,C10","10nF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","3","","",""
"C2,C11,C12","10uF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","3","","",""
"C5,C6,C9","100nF","PCM_Capacitor_THT_US_AKL:C_Disc_D5.1mm_W3.2mm_P5.00mm","3","","",""
"H1,H3","~","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","2","","","C2937625"
"H2","~","MountingHole:MountingHole_3mm_Pad","1","","",""
"PR1,PR2","10KΩ","PCM_Potentiometer_THT_AKL:Potentiometer_Bourns_3296W_Vertical","2","","RM065-203(20K)","C5205022"
"R1,R8","1MΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2","","",""
"R2","3.3KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1","","",""
"R3","2MΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1","","",""
"R4","33KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1","","",""
"R5","1KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","1","","",""
"R6,R7","47KΩ","PCM_Resistor_THT_AKL:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical","2","","",""
"R9","R_Photo","OptoDevice:R_LDR_5.1x4.3mm_P3.4mm_Vertical","1","","GL5506（4-7K）","C11299"
"S1","D203S_TO-5-3","Package_TO_SOT_THT:TO-5-3","1","","D203S","C78793"
"U1","BISS0001_SOP-16","Package_SO:SOP-16_3.9x9.9mm_P1.27mm","1","","BISS0001","C115919"

## KiCad design li-chuang-liang-shan-pai-tian-kong-xing-kai-fa-ban_check_kicadv805_2024-11-05/li-chuang-liang-shan-pai-tian-kong-xing-kai-fa-ban/project/li-chuang-liang-shan-pai-tian-kong-xing-kai-fa-ban.kicad_pcb

Parts:
BT1: Battery_Cell; BAT-SMD_CR1220-2
C1, C3: 10uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C2, C4, C5, C6, C7, C8, C9, C10, C12, C13, C14, C19, C20: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C11: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm; not fitted
C15, C16, C17, C18: 30pF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C22, C24: 2.2uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C23, C25, C26, C27, C28, C29, C30, C31, C32: 100nF; C_0603_1608Metric; not fitted
C33, C34, C35, C36: 30nF; C_0603_1608Metric; not fitted
F1: 5V1A; Fuse_1206_3216Metric
H1: MountingHole_Pad; MountingHole_3mm_Pad
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_USB2.0_16P_Ping_in
J2: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J3: Micro_SD_Card_Det1; microSD_9pin
J4, J5: Conn_02x21_Odd_Even; PinHeader_2x21_P2.54mm_Vertical
LED1: 红; LED_D3.0mm
LED2: 绿; LED_D3.0mm
NT1, NT2, NT3: NetTie_2; short_circuit
R1, R5, R7, R8, R9, R10, R11, R12: 10KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2, R3: 5.1KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 1.5KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6: 2KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R13, R14, R15, R16, R17, R18: 47KΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1, SW2, SW3: SW_DIP_x01; SW_PUSH_6mm_H7.3mm
U1: AZ1117IH-3.3TRE1; SOT-223-3_TabPin2
U2: GD25Q32CTIG; SOP-8_3.9x4.9mm_P1.27mm
U3: GD32F103VET6; LQFP-100_14x14mm_P0.5mm
X1: 8MHz_±20ppm_20pF_HC-49S; Crystal_HC49-U-3Pin_Vertical_change
X2: 32.768kHz_±20ppm_12.5pF_DT-26; Crystal_DS26_D2.0mm_L6.0mm_Horizontal_1EP_style2

Connections:
+3.3V: C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C19.1, C20.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, J2.6, J3.4 (VDD), J4.42, J5.41, NT1.1, R1.1, R4.1, R5.1, R12.1, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, SW1.2, SW2.2, U1.2 (OUT), U2.3 (~WP/SIO2), U2.7 (~HOLD/SIO3), U2.8 (VCC), U3.11 (VDD), U3.21 (VREF+), U3.22 (VDDA), U3.28 (VDD), U3.50 (VDD), U3.75 (VDD), U3.100 (VDD)
+5V: C1.1, C2.1, F1.1, J4.40, J5.39, U1.3 (IN)
+BATT: BT1.1 (+), C5.1, C26.1, U3.6 (VBAT)
/BOOT0: R9.1, U3.94 (BOOT0)
/D+: J1.A6 (D+), J1.B6 (D+), R4.2, U3.71 (PA12)
/D-: J1.A7 (D-), J1.B7 (D-), U3.70 (PA11)
/NRST: C14.1, J2.7, J5.9, R5.2, SW3.2, U3.14 (NRST)
/OSC32+: C17.1, C35.1, U3.8 (PC14), X2.2
/OSC32-: C18.1, C36.1, U3.9 (PC15), X2.1
/OSC+: C15.1, C33.1, U3.12 (OSC_IN), X1.1
/OSC-: C16.1, C34.1, U3.13 (OSC_OUT), X1.3
/PA0_WKUP: J5.4, R8.1, U3.23 (PA0)
/PA1: J5.1, U3.24 (PA1)
/PA2: J5.2, U3.25 (PA2)
/PA3: J5.5, U3.26 (PA3)
/PA4_SPI1_CS#: J5.10, R12.2, U2.1 (~CS), U3.29 (PA4)
/PA5_SPI1_SCLK: J5.11, U2.6 (SCLK), U3.30 (PA5)
/PA6_SPI1_MISO: J5.12, U2.2 (SO/SIO1), U3.31 (PA6)
/PA7_SPI1_MOSI: J5.13, U2.5 (SI/SIO0), U3.32 (PA7)
/PA8: J4.31, U3.67 (PA8)
/PA9_USART1_TX: J2.1, J4.32, U3.68 (PA9)
/PA10_USART1_RX: J2.3, J4.30, U3.69 (PA10)
/PA13_SWDIO: J2.2, J4.29, U3.72 (PA13)
/PA14_SWCLK: J2.4, J4.27, U3.76 (PA14)
/PA15: J4.28, U3.77 (PA15)
/PB0: J5.16, U3.35 (PB0)
/PB1: J5.17, U3.36 (PB1)
/PB2_BOOT1: LED2.2 (A), R7.1, U3.37 (PB2)
/PB3_SWO: J2.5, J4.16, U3.89 (PB3)
/PB4: J4.13, U3.90 (PB4)
/PB5: J4.14, U3.91 (PB5)
/PB6: J4.11, U3.92 (PB6)
/PB7: J4.12, U3.93 (PB7)
/PB8: J4.9, U3.95 (PB8)
/PB9: J4.10, U3.96 (PB9)
/PB10: J5.27, U3.47 (PB10)
/PB11: J5.28, U3.48 (PB11)
/PB12: J5.30, U3.51 (PB12)
/PB13: J5.29, U3.52 (PB13)
/PB14: J5.31, U3.53 (PB14)
/PB15: J5.32, U3.54 (PB15)
/PC0: J5.8, U3.15 (PC0)
/PC1: J5.7, U3.16 (PC1)
/PC2: J5.6, U3.17 (PC2)
/PC3: J5.3, U3.18 (PC3)
/PC4: J5.14, U3.33 (PC4)
/PC5: J5.15, U3.34 (PC5)
/PC6: J4.35, U3.63 (PC6)
/PC7: J4.36, U3.64 (PC7)
/PC8_SDIO_D0: J3.7 (DAT0), J4.33, R15.1, U3.65 (PC8)
/PC9_SDIO_D1: J3.8 (DAT1), J4.34, R14.1, U3.66 (PC9)
/PC10_SDIO_D2: J3.1 (DAT2), J4.25, R18.1, U3.78 (PC10)
/PC11_SDIO_D3: J3.2 (DAT3/CD), J4.26, R17.1, U3.79 (PC11)
/PC12_SDIO_CLK: J3.5 (CLK), J4.23, U3.80 (PC12)
/PC13: J4.5, U3.7 (PC13)
/PD0: J4.24, U3.81 (PD0)
/PD1: J4.21, U3.82 (PD1)
/PD2_SDIO_CMD: J3.3 (CMD), J4.22, R16.1, U3.83 (PD2)
/PD3_SDIO_DET: J3.9 (DET), J4.19, R13.1, U3.84 (PD3)
/PD4: J4.20, U3.85 (PD4)
/PD5: J4.17, U3.86 (PD5)
/PD6: J4.18, U3.87 (PD6)
/PD7: J4.15, U3.88 (PD7)
/PD8: J5.33, U3.55 (PD8)
/PD9: J5.34, U3.56 (PD9)
/PD10: J5.35, U3.57 (PD10)
/PD11: J5.36, U3.58 (PD11)
/PD12: J5.37, U3.59 (PD12)
/PD13: J5.38, U3.60 (PD13)
/PD14: J4.37, U3.61 (PD14)
/PD15: J4.38, U3.62 (PD15)
/PE0: J4.7, U3.97 (PE0)
/PE1: J4.8, U3.98 (PE1)
/PE2: J4.6, U3.1 (PE2)
/PE3: J4.3, U3.2 (PE3)
/PE4: J4.4, U3.3 (PE4)
/PE5: J4.1, U3.4 (PE5)
/PE6: J4.2, U3.5 (PE6)
/PE7: J5.18, U3.38 (PE7)
/PE8: J5.19, U3.39 (PE8)
/PE9: J5.20, U3.40 (PE9)
/PE10: J5.21, U3.41 (PE10)
/PE11: J5.22, U3.42 (PE11)
/PE12: J5.23, U3.43 (PE12)
/PE13: J5.24, U3.44 (PE13)
/PE14: J5.25, U3.45 (PE14)
/PE15: J5.26, U3.46 (PE15)
/VUSB: F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, H1.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.8, J3.6 (VSS), J3.10 (SHIELD), J4.39, J4.41, J5.40, J5.42, LED1.1 (K), NT2.2, NT3.2, R2.1, R3.1, R6.2, R7.2, R10.2, R11.2, SW3.1, U1.1, U2.4 (GND), U3.10 (VSS), U3.20 (VREF-), U3.27 (VSS), U3.74 (VSS), U3.99 (VSS), X1.2, X2.3
unnamed: C12.2, R8.2, R10.1, SW1.1
unnamed: C13.2, R9.2, R11.1, SW2.1
unnamed: C22.1, C23.1, NT3.1, U3.49 (VSS)
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R3.2
unnamed: LED1.2 (A), R1.2
unnamed: LED2.1 (K), R6.1
unnamed: C24.1, C25.1, U3.73 (NC)
unnamed: NT1.2, NT2.1, U3.19 (VSSA)

Notes on the sheet:
SMT生产兼容一览 100脚芯片目录 pin19 pin49 pin73 GD32F407Vx 3V3 float float GD32F470Vx 3V3 float float GD32F103Vx GND GND float STM32F407Vx 3V3 2.2uF to GND 2.2uF to GND STM32F103VX GND GND float AT32F403A/407Vx GND GND float AT32F435/437Vx float float float

Board: 2 copper layers, 58.0 x 85.0 mm, 73 parts (20 on the bottom side), 98 nets.
